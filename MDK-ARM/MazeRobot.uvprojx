# Keil uVision project MazeRobot.uvprojx, settings and files
target MazeRobot (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: MazeRobot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB
  c include: ..\USER;..\APP;..\DRIVER;..\SYSTEM
  asm include: ..\USER;..\APP;..\DRIVER;..\SYSTEM
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c config.h
  group APP
    ../APP/: maze.c maze.h
  group DRIVER
    ../DRIVER/: bsp_gpio.c delay.c motor.c ultrasonic.c ir_sensor.c uart.c bsp_gpio.h delay.h motor.h ultrasonic.h ir_sensor.h uart.h
  group SYSTEM
    ../SYSTEM/: system_stm32f103.c system_stm32f103.h stm32f103_min.h
  group CORE
    ../CORE/: startup_stm32f103c8tx.s
